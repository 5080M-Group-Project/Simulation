Commit message: urdf

File: robot_description/lucasURDF/urdf/lucasURDF.urdf (robot description, URDF)
Before this commit: robot lucasURDF, 5 links, 4 joints
Links:
- link shin: mass 1.42 -> 0.79162
- link thigh: mass 2.4339 -> 1.0138
